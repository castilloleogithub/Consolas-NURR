# IAR project DSY-6.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Silicon Laboratories\C8051F040.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Firmware RPS\Library RPS\Application; C:\Firmware RPS\Library RPS\Drivers; C:\Firmware RPS\DSY-6
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: fondo.c main_DSY.c module_DSY.c ssd1963_text.c
  group Application
    ../Library RPS/Application/: MemoryBank.c ProcessCode.c SafetyBus.c Supervisor.c
  group Drivers
    ../Library RPS/Drivers/: adc.c CAN.c I2C.c
